# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32L475xx
  c include: .;rt-thread\include;.;applications;board;board\CubeMX_Config\Inc;board\ports;libraries\HAL_Drivers;libraries\HAL_Drivers\config;packages\aht10-latest;packages\at_device-v2.0.4\inc;packages\at_device-v2.0.4\class\esp8266;packages\cJSON-latest;packages\mymqtt-latest\MQTTPacket\src;packages\mymqtt-latest\MQTTClient-C;packages\onenet-latest\inc;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;rt-thread\components\drivers\sensors;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\net\at\include;rt-thread\components\net\at\at_socket;rt-thread\components\net\netdev\include;rt-thread\components\net\sal_socket\include;rt-thread\components\net\sal_socket\include\socket;rt-thread\components\net\sal_socket\impl;rt-thread\components\net\sal_socket\include\dfs_net;rt-thread\components\net\sal_socket\include\dfs_net\sys_select;rt-thread\components\net\sal_socket\include\socket\sys_socket;libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc;libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include;libraries\STM32L4xx_HAL\CMSIS\Include;.\packages\webclient-v2.1.2\inc;.\packages\lvgl;.\packages\lvgl\keypad_encoder;.\packages\lvgl\env_support\rt-thread;.\packages\lvgl\app;.\packages\lvgl\app\custom;.\packages\lvgl\app\generated;.\packages\lvgl\app\generated\guider_fonts;.\packages\lvgl\src;.\packages\lvgl\src\font;.\packages\lvgl\porting
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
    ./applications/: sample_04_aht10_read_data.c sample_04_store_data_r.c lcd_sample.c pin_sample.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32l4xx_hal_msp.c
    board/ports/: drv_qspi_flash.c sensor_port.c
    libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l475xx.s
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_qspi.c drv_soft_i2c.c drv_common.c
    ./board/ports/: drv_lcd.c sdcard_port.c
  group aht10
    packages/aht10-latest/: aht10.c sensor_asair_aht10.c
  group at_device
    packages/at_device-v2.0.4/src/: at_device.c
    packages/at_device-v2.0.4/class/esp8266/: at_device_esp8266.c at_socket_esp8266.c
    packages/at_device-v2.0.4/samples/: at_sample_esp8266.c
  group cJSON
    packages/cJSON-latest/: cJSON.c cJSON_Utils.c
  group my-mqtt
    packages/mymqtt-latest/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    packages/mymqtt-latest/MQTTClient-C/: mqtt_client.c
    packages/mymqtt-latest/samples/: mqtt_sample.c
  group onenet
    packages/onenet-latest/samples/: onenet_sample.c
    ./packages/onenet-latest/src/: onenet_mqtt.c onenet_http.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ./rt-thread/components/drivers/spi/: spi_msd.c
  group Sensors
    rt-thread/components/drivers/sensors/: sensor.c sensor_cmd.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    rt-thread/components/libc/compilers/common/: time.c
  group AT
    rt-thread/components/net/at/src/: at_utils.c at_cli.c at_client.c
    rt-thread/components/net/at/at_socket/: at_socket.c
  group netdev
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    rt-thread/components/net/sal_socket/src/: sal_socket.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal_socket/impl/: af_inet_at.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
  group STM32_HAL
    libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    libraries/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_gpio.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_qspi.c
  group WebClient
    ./packages/webclient-v2.1.2/src/: webclient.c
  group lvgl_src
    ./packages/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ./packages/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./packages/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./packages/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./packages/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_malloc_builtin.c lv_math.c lv_mem.c lv_memcpy_builtin.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./packages/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ./packages/lvgl/src/draw/gd32_ipa/: lv_gpu_gd32_ipa.c
    ./packages/lvgl/src/draw/nxp/: lv_gpu_nxp.c
    ./packages/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ./packages/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ./packages/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ./packages/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ./packages/lvgl/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ./packages/lvgl/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_rect.c lv_gpu_nxp_vglite.c
    ./packages/lvgl/src/layouts/flex/: lv_flex.c
    ./packages/lvgl/src/layouts/grid/: lv_grid.c
    ./packages/lvgl/src/libs/bmp/: lv_bmp.c
    ./packages/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ./packages/lvgl/src/libs/freetype/: lv_freetype.c
    ./packages/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./packages/lvgl/src/libs/gif/: gifdec.c lv_gif.c
    ./packages/lvgl/src/libs/png/: lodepng.c lv_png.c
    ./packages/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./packages/lvgl/src/libs/rlottie/: lv_rlottie.c
    ./packages/lvgl/src/libs/sjpg/: lv_sjpg.c tjpgd.c
    ./packages/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ./packages/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ./packages/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ./packages/lvgl/src/others/gridnav/: lv_gridnav.c
    ./packages/lvgl/src/others/ime/: lv_ime_pinyin.c
    ./packages/lvgl/src/others/imgfont/: lv_imgfont.c
    ./packages/lvgl/src/others/monkey/: lv_monkey.c
    ./packages/lvgl/src/others/msg/: lv_msg.c
    ./packages/lvgl/src/others/snapshot/: lv_snapshot.c
    ./packages/lvgl/src/themes/basic/: lv_theme_basic.c
    ./packages/lvgl/src/themes/default/: lv_theme_default.c
    ./packages/lvgl/src/themes/mono/: lv_theme_mono.c
    ./packages/lvgl/src/widgets/animimg/: lv_animimg.c
    ./packages/lvgl/src/widgets/arc/: lv_arc.c
    ./packages/lvgl/src/widgets/bar/: lv_bar.c
    ./packages/lvgl/src/widgets/btn/: lv_btn.c
    ./packages/lvgl/src/widgets/btnmatrix/: lv_btnmatrix.c
    ./packages/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./packages/lvgl/src/widgets/canvas/: lv_canvas.c
    ./packages/lvgl/src/widgets/chart/: lv_chart.c
    ./packages/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ./packages/lvgl/src/widgets/colorwheel/: lv_colorwheel.c
    ./packages/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ./packages/lvgl/src/widgets/img/: lv_img.c
    ./packages/lvgl/src/widgets/imgbtn/: lv_imgbtn.c
    ./packages/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ./packages/lvgl/src/widgets/label/: lv_label.c
    ./packages/lvgl/src/widgets/led/: lv_led.c
    ./packages/lvgl/src/widgets/line/: lv_line.c
    ./packages/lvgl/src/widgets/list/: lv_list.c
    ./packages/lvgl/src/widgets/menu/: lv_menu.c
    ./packages/lvgl/src/widgets/meter/: lv_meter.c
    ./packages/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ./packages/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ./packages/lvgl/src/widgets/roller/: lv_roller.c
    ./packages/lvgl/src/widgets/slider/: lv_slider.c
    ./packages/lvgl/src/widgets/span/: lv_span.c
    ./packages/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ./packages/lvgl/src/widgets/spinner/: lv_spinner.c
    ./packages/lvgl/src/widgets/switch/: lv_switch.c
    ./packages/lvgl/src/widgets/table/: lv_table.c
    ./packages/lvgl/src/widgets/tabview/: lv_tabview.c
    ./packages/lvgl/src/widgets/textarea/: lv_textarea.c
    ./packages/lvgl/src/widgets/tileview/: lv_tileview.c
    ./packages/lvgl/src/widgets/win/: lv_win.c
  group lvgl_port
    ./packages/lvgl/env_support/rt-thread/: lv_rt_thread_port.c
    ./packages/lvgl/porting/: lv_port_disp.c lv_port_indev.c
  group lvgl_app
    ./packages/lvgl/app/: lv_gui_guider_demo.c
    ./packages/lvgl/app/custom/: custom.c
    ./packages/lvgl/app/generated/: events_init.c gui_guider.c setup_scr_screen.c
    ./packages/lvgl/app/generated/guider_fonts/: lv_font_simsun_12.c
